# IAR project temp rh eeprom rtc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: E:\ArquivosProjetos\ARM\Projetos de Aulas e Outros\bibliotecas; E:\ArquivosProjetos\ARM\Projetos de Aulas e Outros\PROJETOS PRO GITHUB\temp+rh - external eeprom - rtc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: temp rh eeprom rtc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../bibliotecas/driverlib/ewarm/Exe/: driverlib.a
    ./: functions.c temp rh eeprom rtc.c
    ../../bibliotecas/utils/: uartstdio.c
